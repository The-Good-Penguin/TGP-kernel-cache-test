FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Update-default-env-for-qemu-test-booting.patch"

