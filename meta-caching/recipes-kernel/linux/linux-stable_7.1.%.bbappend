#
# Add the bootcache patches in.
#

require bootcache-config.inc
require bootcache.inc